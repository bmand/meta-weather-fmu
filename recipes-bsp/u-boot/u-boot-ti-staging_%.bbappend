# Copyright (C) 2019 Bertrand Mandrin
# Released under the MIT license (see COPYING.MIT for the terms)
include u-boot-common.inc
